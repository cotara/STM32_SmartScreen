# IAR project smartScreen.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103T6 ST STM32F103T6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: STM32F10x_StdPeriph_Driver\inc; STM32F10x_StdPeriph_Driver\src; CMSIS; $PROJ_DIR$; DS18B20; EEPROM; BME68x-Sensor-API-master
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartScreen.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\STM\STM32_SmartScreen\STMF103\Config\STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c stm32f10x_it.c
    CMSIS/: stm32f10x.h system_stm32f10x.c
  group BME680
    BME68x-Sensor-API-master/: bme68x.c bme68x.h bme68x_defs.h userBME680.c
  group DS18B20
    DS18B20/: user_ds18b20.c
  group EEPROM
    EEPROM/: i2c_ee.c
  group STM32Std
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
    ./: startup_stm32f10x_md.s
  group User
    ./: LED_user.c myNextion.c user_GPIO.c user_TIMER.c user_USART.c
