# IAR project smartScreen.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103T6 ST STM32F103T6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: STM32F10x_StdPeriph_Driver\inc; STM32F10x_StdPeriph_Driver\src; CMSIS; $PROJ_DIR$; DS18B20
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartScreen.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: C:\Users\User\Documents\Projects\Nextion\Olimex H103\Nextion\CMSIS\stm32f103x6_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c stm32f10x_it.c
    CMSIS/: stm32f10x.h system_stm32f10x.c
  group DS18B20
    DS18B20/: user_ds18b20.c
  group STM32Std
    STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
    ./: startup_stm32f10x_md.s
  group User
    ./: myNextion.c user_GPIO.c user_TIMER.c user_USART.c
